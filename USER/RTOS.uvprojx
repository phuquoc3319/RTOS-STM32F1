# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FW LIB\inc;..\CUSTOM LIB;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\CUSTOM LIB\delay;..\CUSTOM LIB\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CUSTOM LIB
    ../CUSTOM LIB/delay/: delay.c
    ../CUSTOM LIB/sys/: sys.c
  group FW LIB
    ../FW LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group freeRTOS
    ../FreeRTOS/: tasks.c queue.c timers.c croutine.c event_groups.c list.c
    ../FreeRTOS/portable/MemMang/: heap_1.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
